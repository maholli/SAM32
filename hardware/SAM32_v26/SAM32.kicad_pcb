# Repository maholli/SAM32

File README.md:

# SAM32

<p align="middle">
  
  <br><br>
  
</p>

You can control this board with python or arduino! A basic text-editor is all you need to get started.

## [⭐ See the SAM32 Guide for tutorials, design resources, and more!](https://www.notion.so/maholli/SAM32-Guides-6b7e8ca318ff49418eec16e975d98f5d)
<br><br><br><br>
### Easily Add Hardware Capability

Compatibility with [Adafruit Feather Wings](https://www.adafruit.com/category/814) makes adding sound, displays, and even GPS a breeze for the SAM32.

### Want to Help Out?

visit https://github.com/maholli/SAM32/projects/1 for a current list of software tasks in need of YOUR help! :point_left:

<br><br><br><br>

#### Thank you Adafruit for the time/money spent developing CircuitPython! (and for the beautiful photos of the SAM32)

## KiCad design hardware/SAM32_v26/SAM32.kicad_pcb

File hardware/README.md:

## [⭐ See the SAM32 Guide for tutorials, design resources, and more!](https://www.notion.so/maholli/SAM32-Guides-6b7e8ca318ff49418eec16e975d98f5d)

Parts:
C2, C4, C6, C7, C12: 10uF; C_0402_1005Metric
C3, C5, C9, C10, C11: 1uF; C_0402_1005Metric
C13, C14: 22pF; C_0402_1005Metric
C15: 0.1uF; C_0402_1005Metric
CHRG1: ORANGE LED; LED_0402_1005Metric
D1: RB550V; D_SOD-323
D2: WS2812B; LED3535
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Silkscreen
GRN1: GREEN LED; LED_0603_1608Metric
J1: 10118194-0001LF
J2: Conn_01x14; PinHeader_1x14_P2.54mm_Vertical
J3: 5031821852; MOLEX_503182-1853
J4: B2B-PH-SM4-TB; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal
J5: Conn_02x12_Odd_Even; PinSocket_2x12_P1.27mm_Vertical_SMD
J7: Conn_01x17; PinSocket_1x17_P2.54mm_Vertical
J96, J97: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
JP1: Bridged Jumper; Jumper3_Small
L1: 10uH; L_0806_2016Metric
Q3: DMG341; SOT23-R
R1, R4, R6, R9, R10, R11, R12, R13, R14, R15: 10K; R_0402_1005Metric
R2: 2.2K; R_0402_1005Metric
R3, R5: 100K; R_0402_1005Metric
R7: 1K; R_0402_1005Metric
SW1: KMR231NG LFS; BTN_KMR2_4.6X2.8
U1: 74AHC1G125; SOT-23-5
U2: ATSAMD51J20A-AU; QFP50P1200X1200X120-64N
U3: ESP32_WROOM32_SKINNY; WROOM32_SKINNY
U4: MCP73831T-2ACI/OT; SOT23-5
U5: AP2112K-3.3TRG1; SOT23-5
X1: ST3215SB; Crystal_SMD_MicroCrystal_CC7V-T1A-2Pin_3.2x1.5mm

Connections:
+3V3: C2.1, C3.1, C5.1, C6.1, C10.1, C15.1, D2.1 (VDD), J3.4 (VDD), J5.2, J5.22, J7.2, R1.1, R9.1, R10.1, R13.1, R14.1, R15.1, U1.5 (VCC), U2.4 (PA03), U2.8 (VDDANA), U2.21 (VDDIO), U2.34 (VDDIO1), U2.48 (VDDIO2), U2.56 (VDDIO3), U3.2 (3.3V), U5.5 (OUT)
/BATTERY: R3.2, R5.1, U2.15 (PA06)
/DTR: R11.1, U2.23 (PB10)
/EN: R4.1, U5.3 (EN)
/LED1: R2.2, U2.51 (PA27)
/PROG: R6.1, U4.5 (PROG)
/RX2: U2.40 (PB17), U3.35 (TXD0)
/TX2: R15.2, U2.39 (PB16), U3.34 (RXD0)
/USB+: J1.3 (D+), U2.46 (PA25)
/USB-: J1.2 (D-), U2.45 (PA24)
/XTAL1: C13.1, U2.1 (PA00), X1.2
/XTAL2: C14.1, U2.2 (PA01), X1.1
/~RESET: C9.2, JP1.1 (A), R9.2, SW1.A, SW1.A' (P1), U2.52 (RESETN)
/~RTS: R12.1, U2.24 (PB11)
AIN6: J5.12, U2.5 (PB04)
AIN7: J2.10, U2.6 (PB05)
AIN8: J2.11, U2.9 (PB06)
AIN9: J2.14, U2.10 (PB07)
D16: J7.17, U2.16 (PA07)
D19: U2.19 (PA10)
D20: U2.20 (PA11)
D31: J7.10, U2.31 (PA14)
D35: J7.9, U2.35 (PA16)
D36: J7.8, U2.36 (PA17)
D37: J7.7, U2.37 (PA18)
D38: J2.1, U2.38 (PA19)
D41: J7.6, U2.41 (PA20)
D42: J7.5, U2.42 (PA21)
D43: J7.3, U2.43 (PA22)
D44: JP1.3 (B), U2.44 (PA23)
D44-RST: J7.1, JP1.2 (C)
D49: J2.3, U2.49 (PB22)
D50: U2.50 (PB23)
D59: J2.6, U2.59 (PB30)
D60: J2.7, U2.60 (PB31)
D61: J2.8, U2.61 (PB00)
DAC0: J2.9, U2.3 (PA02)
DAC1: J2.5, U2.14 (PA05)
ESP_CS: J5.20, U1.1, U2.28 (PB15), U3.23 (IO15/A2_3)
ESP_MISO: U1.2, U3.31 (IO19)
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.1, C10.2, C11.2, C12.1, C13.2, C14.2, C15.2, D2.3 (VSS), GRN1.2, J1.5 (GND), J1.8, J1.9 (SHIELD), J3.6 (VSS), J3.SH1 (SHIELD), J3.SH2 (SHIELD), J3.SH3 (SHIELD), J3.SH4 (SHIELD), J3.SH5 (SHIELD), J4.2, J5.4, J5.24, J7.4, J7.16, R5.2, R6.2, SW1.B (S), SW1.B' (S1), U1.3 (GND), U2.7 (GND), U2.22 (GND1), U2.33 (GND2), U2.47 (GND3), U2.54 (GND4), U3.1 (GND), U3.15 (GND), U3.38 (GND), U3.P$1 (GND), U4.2 (VSS), U5.2 (GND)
IO4: J5.23, U3.26 (IO4/A2_0)
IO12: J5.6, U2.63 (PB02), U3.14 (IO12/A2_5)
IO13: J5.8, U2.62 (PB01), U3.16 (IO13/A2_4)
IO14: J5.5, U2.64 (PB03), U3.13 (IO14/A2_6)
IO16: J5.21, U3.27 (IO16)
IO17: J5.19, U3.28 (IO17)
IO21: J5.17, U3.33 (IO21)
IO25: J5.10, U3.10 (IO25/DAC1/A2_8)
IO26: J5.9, U3.11 (IO26/DAC2/A2_9)
IO27: J5.7, U3.12 (IO27/A2_7)
IO32: J5.11, U3.8 (IO32/A1_4/X32P)
IO33: J5.13, U3.9 (IO33/A1_5/X32N)
IO34: J5.15, U3.6 (I34/A1_6)
IO35: J5.14, U3.7 (I35/A1_7)
IO36: J5.16, U2.12 (PB09), U3.4 (IO36/SEN_VP/A1_0)
IO39: J5.18, U2.11 (PB08), U3.5 (IO39/SEN_VN/A1_3)
MISO: J3.7 (DAT0), J7.13, U1.4, U2.27 (PB14)
MOSI: J3.3 (CMD), J7.12, U2.25 (PB12), U3.30 (IO18)
unnamed: C11.1, C12.2, L1.1, U2.53 (VDDCORE)
unnamed: CHRG1.2, R7.2
unnamed: D2.4 (DIN), U2.32 (PA15)
unnamed: GRN1.1, R2.1
unnamed: L1.2, U2.55 (VSW)
unnamed: R7.1, U4.1 (STAT)
unnamed: R11.2, U3.25 (IO0/A2_1)
unnamed: R12.2, U3.3 (EN)
RX1: J7.14, U2.30 (PA13)
SCK: J3.5 (CLK), J7.11, U2.26 (PB13), U3.29 (IO5)
SCL: J2.12, R13.2, U2.18 (PA09), U3.36 (IO22)
SDA: J2.13, R14.2, U2.17 (PA08), U3.37 (IO23)
SWCLK: J5.3, R10.2, U2.57 (PA30)
SWDIO: J5.1, U2.58 (PA31)
TX1: J7.15, U2.29 (PA12)
VBAT: C7.1, J2.2, J4.1, Q3.3 (D), R3.1, U4.3 (VBAT)
VIN: C4.1, D1.1 (K), J2.4, Q3.2 (S), R4.2, U5.1 (IN)
VUSB: CHRG1.1, D1.2 (A), J1.1 (VDD), Q3.1 (G), U4.4 (VDD)
xSDCS: J3.2 (CD/DAT3), R1.2, U2.13 (PA04)

Notes on the sheet:
REGULATOR
10K = 100mA
5.0K = 200mA
2.0K = 500mA
1.0K = 1000mA
BATTERY CHARGING
MICROSD CARD
USB CONN.
DECOUPLING
WROOM ESP32
PCCD0
PCCD1
PCCD2
PCCD3
PCCD4
PCCD5
PCCD6
PCCD7
UART COM5
(CAMERA INTERFACE)
PCCCLK
PCCDEN2
PCCDEN1
SPI COM4
ESP JTAG
ADC1
SAMD JTAG
SAM32 v2.6
LIPO CONN.
RESET
MOUNTING HOLES
THRU-HOLE HEADERS (SAMD51 I/O)
SURFACE MOUNT HEADER (JTAG and SAMD/ESP32 GPIO)
PARALLEL CAPTURE CONTROL
Hold DTR low during boot for serial bootloader access
NEOPIXEL
SAMD51
FIDUCIALS

Board: 4 copper layers, 53.4 x 23.4 mm, 52 parts (0 on the bottom side), 75 nets.

## KiCad design hardware/SAM32.kicad_pcb

Parts:
C1, C3, C5, C9, C10, C11: 1uF; C_0402_1005Metric
C2, C4, C6, C7, C12: 10uF; C_0402_1005Metric
C8: 4.5 nF; C_0402_1005Metric
C13, C14: 22pF; C_0402_1005Metric
C15: 0.1uF; C_0402_1005Metric
CHRG1: ORANGE LED; LED_0402_1005Metric
D1: MBR120; D_SC-80
D2: WS2812B; LED3535
GRN1: GREEN LED; LED_0603_1608Metric
J1: 10118194-0001LF
J2: Conn_01x14; PinHeader_1x14_P2.54mm_Vertical
J3: 5031821852; MOLEX_503182-1853
J4: B2B-PH-SM4-TB; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal
J5: NPTC072KFMS-RC; NPPC_0.100in_headers_2ROW
J7: Conn_01x17; PinSocket_1x17_P2.54mm_Vertical
J96, J97: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
L1: 10uH; L_0806_2016Metric
Q3: DMG341; SOT23-R
R1, R4, R6, R9, R10, R11, R12: 10K; R_0402_1005Metric
R2: 2.2K; R_0402_1005Metric
R3, R5: 100K; R_0402_1005Metric
R7: 1K; R_0402_1005Metric
R8: 1M; R_0402_1005Metric
R15, R16, R17: 0; R_0402_1005Metric
SW1: KMR231NG LFS; BTN_KMR2_4.6X2.8
TP1, TP2: TESTPOINTPAD2MM; TestPoint_Pad_D1.5mm
U1: MAX3202EETT+T; WLP-4-0.5
U2: ATSAMD51J20A-AU; QFP50P1200X1200X120-64N
U3: ESP32_WROOM32_SKINNY; WROOM32_SKINNY
U4: MCP73831T-2ACI/OT; SOT23-5
U5: AP2112K-3.3TRG1; SOT23-5
X1: ST3215SB; Crystal_SMD_MicroCrystal_CC7V-T1A-2Pin_3.2x1.5mm

Connections:
+3V3: C1.2, C2.1, C3.1, C5.1, C6.1, C10.1, C15.1, D2.1 (VDD), J2.2, J3.4 (VDD), R1.1, R9.1, R10.1, U2.8 (VDDANA), U2.21 (VDDIO), U2.34 (VDDIO1), U2.48 (VDDIO2), U2.56 (VDDIO3), U3.2 (3.3V), U5.5 (OUT)
/AREF: C1.1, U2.4 (PA03)
/DTR: R12.1, U2.24 (PB11)
/EN: R4.1, U5.3 (EN)
/LED1: R2.2, U2.51 (PA27)
/PROG: R6.1, U4.5 (PROG)
/SWCLK: R10.2, TP1.1, U2.57 (PA30)
/SWDIO: TP2.1, U2.58 (PA31)
/TCK: R16.1, U2.62 (PB01)
/TDI: R15.1, U2.63 (PB02)
/TMS: R17.1, U2.61 (PB00)
/USB+: J1.3 (D+), U1.4 (IO2), U2.46 (PA25)
/USB-: J1.2 (D-), U1.1 (IO1), U2.45 (PA24)
/VBAT_MES: R3.2, R5.1, U2.15 (PA06)
/XTAL1: C13.1, U2.1 (PA00), X1.2
/XTAL2: C14.1, U2.2 (PA01), X1.1
/~RESET: C9.2, R9.2, SW1.A, SW1.A' (P1), U2.52 (RESETN)
/~RTS: R11.1, U2.23 (PB10)
AIN0: J2.13, U2.11 (PB08)
AIN1: J2.14, U2.12 (PB09)
AIN2: U2.17 (PA08)
AIN3: U2.18 (PA09)
AIN6: J2.9, U2.5 (PB04)
AIN7: J2.10, U2.6 (PB05)
AIN8: J2.11, U2.9 (PB06)
AIN9: J2.12, U2.10 (PB07)
D19: U2.19 (PA10)
D20: U2.20 (PA11)
D29: J7.11, U2.29 (PA12)
D30: J7.10, U2.30 (PA13)
D31: J7.9, U2.31 (PA14)
D35: J7.8, U2.35 (PA16)
D36: J7.7, U2.36 (PA17)
D37: J7.6, U2.37 (PA18)
D38: J7.5, U2.38 (PA19)
D41: J7.4, U2.41 (PA20)
D42: J7.3, U2.42 (PA21)
D43: J7.2, U2.43 (PA22)
D44: J7.1, U2.44 (PA23)
D49: J2.3, U2.49 (PB22)
D50: U2.50 (PB23)
D59: J2.5, U2.59 (PB30)
D60: J2.6, U2.60 (PB31)
D64: J2.7, U2.64 (PB03)
DAC0: J2.8, U2.3 (PA02)
DAC1: J2.4, U2.14 (PA05)
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.2, C11.2, C12.1, C13.2, C14.2, C15.2, D2.3 (VSS), GRN1.2, J1.5 (GND), J2.1, J3.6 (VSS), J3.SH1 (SHIELD), J3.SH2 (SHIELD), J3.SH3 (SHIELD), J3.SH4 (SHIELD), J3.SH5 (SHIELD), J4.1, J7.17, R5.2, R6.2, R8.2, SW1.B (S), SW1.B' (S1), U1.2 (GND), U2.7 (GND), U2.22 (GND1), U2.33 (GND2), U2.47 (GND3), U2.54 (GND4), U3.1 (GND), U3.15 (GND), U3.38 (GND), U3.P$1 (GND), U4.2 (VSS), U5.2 (GND)
IO4: J5.8, U3.26 (IO4/A2_0)
IO15: J5.3, U3.23 (IO15/A2_3)
IO16: J5.1, U3.27 (IO16)
IO17: J5.2, U3.28 (IO17)
IO21: J5.9, U3.33 (IO21)
IO25: J5.6, U3.10 (IO25/DAC1/A2_8)
IO26: J5.7, U3.11 (IO26/DAC2/A2_9)
IO27: J5.14, U3.12 (IO27/A2_7)
IO32: J5.5, U3.8 (IO32/A1_4/X32P)
IO33: J5.13, U3.9 (IO33/A1_5/X32N)
IO34: J5.4, U3.6 (I34/A1_6)
IO35: J5.12, U3.7 (I35/A1_7)
IO36: J5.10, U3.4 (IO36/SEN_VP/A1_0)
IO39: J5.11, U3.5 (IO39/SEN_VN/A1_3)
MISO: J3.7 (DAT0), J7.14, U2.27 (PB14), U3.31 (IO19)
MOSI: J3.3 (CMD), J7.13, U2.25 (PB12), U3.30 (IO18)
unnamed: C4.1, D1.1, Q3.2 (S), R4.2, U5.1 (IN)
unnamed: C11.1, C12.2, L1.1, U2.53 (VDDCORE)
unnamed: CHRG1.2, R7.2
unnamed: D2.4 (DIN), U2.32 (PA15)
unnamed: GRN1.1, R2.1
unnamed: L1.2, U2.55 (VSW)
unnamed: R1.2, U2.39 (PB16), U3.34 (RXD0)
unnamed: R7.1, U4.1 (STAT)
unnamed: R11.2, U3.25 (IO0/A2_1)
unnamed: R12.2, U3.3 (EN)
unnamed: R15.2, U3.14 (IO12/A2_5)
unnamed: R16.2, U3.16 (IO13/A2_4)
unnamed: R17.2, U3.13 (IO14/A2_6)
unnamed: U2.40 (PB17), U3.35 (TXD0)
SCK: J3.5 (CLK), J7.12, U2.26 (PB13), U3.29 (IO5)
SCL: J7.15, U2.13 (PA04), U3.36 (IO22)
SDA: J7.16, U2.16 (PA07), U3.37 (IO23)
SD_CS: J3.2 (CD/DAT3), U2.28 (PB15)
VBAT: C7.1, J4.2, Q3.3 (D), R3.1, U4.3 (VBAT)
VUSB: CHRG1.1, D1.2, J1.1 (VDD), Q3.1 (G), U1.3 (VCC), U4.4 (VDD)
~: C8.1, J1.8, J1.9 (SHIELD), R8.1

Notes on the sheet:
REGULATOR
10K = 100mA
5.0K = 200mA
2.0K = 500mA
1.0K = 1000mA
BATTERY CHARGING
MICROSD CARD
ESD PROT.
USB CONN.
DECOUPLING
WROOM ESP32
PCCD0
PCCD1
PCCD2
PCCD3
PCCD4
PCCD5
PCCD6
PCCD7
UART COM5
(CAMERA INTERFACE)
PCCCLK
PCCDEN2
PCCDEN1
TC6
TC4
SPI COM4
ESP JTAG
ADC1
SAMD JTAG
SAM32
SAMD51 +ESP32-WROOM + microSD
2.1
LIPO CONN.
RESET
TC7
CAN Tx
CAN Rx
MOUNTING HOLES
THRU-HOLE HEADERS (SAMD51 I/O)

Board: 4 copper layers, 53.4 x 23.4 mm, 53 parts (0 on the bottom side), 79 nets.

## KiCad design lab64_SAM32/lab64_SAM32.kicad_pcb

Board: 2 copper layers, 3 parts (0 on the bottom side), 5 nets, no tracks yet.

Parts:
J1: 10118194-0001LF; FRAMATOME_10118194-0001LF
J2: 503182-1853; MOLEX_503182-1853
MOD1: ESP32-WROOM-32; ESP32-WROOM-32D

Connections:
+3V3: J2.4, MOD1.2
/MISO: J2.7, MOD1.31
/MOSI: J2.3, MOD1.30
/SCK: J2.5, MOD1.29
GND: J1.5, J2.6, J2.SH1, J2.SH2, J2.SH3, J2.SH4, J2.SH5, MOD1.1, MOD1.15, MOD1.38, MOD1.39

## Code that names these connections

File firmware/default-files/default_v23/main.py:

# general blink routine for neopixel
# should work on all boards with an "NEOPIXEL" pin defined in firmware
#
# M.Holliday

import time
import board, neopixel, digitalio

sd_cs        =   digitalio.DigitalInOut(board.xSDCS)
rts          =   digitalio.DigitalInOut(board.RTS)
dtr          =   digitalio.DigitalInOut(board.DTR)
sd_cs.direction        =  digitalio.Direction.OUTPUT
rts.direction          =  digitalio.Direction.OUTPUT
dtr.direction          =  digitalio.Direction.OUTPUT

sd_cs.value     = 1
rts.value       = 0
dtr.value       = 0

pixel = neopixel.NeoPixel(board.NEOPIXEL, 1, brightness=0.5, auto_write=False)

def wheel(pos):
    # Input a value 0 to 255 to get a color value.
    # The colours are a transition r - g - b - back to r.
    if pos < 0 or pos > 255:
        r = g = b = 0
    elif pos < 85:
        r = int(pos * 3)
        g = int(255 - pos*3)
        b = 0
    elif pos < 170:
        pos -= 85
        r = int(255 - pos*3)
        g = 0
        b = int(pos*3)
    else:
        pos -= 170
        r = 0
        g = int(pos*3)
        b = int(255 - pos*3)
    return (r, g, b)

def rainbow_cycle(wait):
    for j in range(255):
        pixel_index = (256 // 1) + j
        pixel[0] = wheel(pixel_index & 255)
        pixel.show()
        time.sleep(wait)

######################### MAIN LOOP ##############################
while True:
     rainbow_cycle(0.01)

## Commit log

2018-10-24 initial commit w/ datasheets
2018-10-24 0OHM jumpers on ESP32 TxRx
2018-10-25 1st placement + repo clean
2018-10-25 minor schematic cleanup
2018-10-26 minor schematic clean-up
2018-10-26 major placement and 3D objects
2018-10-26 power routed
2018-10-26 roughing in critical routes
2018-10-26 tweaking critical routes
2018-10-26 critical routing finished
2018-10-26 small tweaks
2018-10-27 roughing in bulk IO
2018-10-27 top SMD header routed
2018-10-27 done routing, minor cleanup left
2018-10-28 routing finished, still need to polish
2018-10-28 R and C ref des cleaned up
2018-10-28 some silkscreen finished
2018-10-28 gitignore
2018-10-28 finished silkscreen + interactive BOM
2018-10-28 adding digikey cart export
2018-10-28 small readme update
2018-10-28 readme update
2018-10-28 playing with github pages
2018-10-28 organizing folders
2018-10-28 BOM value cleanup
2018-10-29 changed board name
2018-10-29 layout DRC
2018-10-29 updating BOM
2018-10-29 layout review w/ Steve
2018-10-31 back to SAM32 name
2018-12-02 adding firmware and board pictures
2018-12-02 adding blink.py
2018-12-09 updated firmware files and added update-bootloader UF2
2018-12-13 updating to v1g - MacOS fix?
2018-12-28 adding esp32 programming via samd51 & sd card!
2018-12-28 instructions for programming esp32
2018-12-29 updating hardware to v2
2019-01-20 adding firmware for SAM32_v2a
2019-01-20 updating esp32 programming scripts
2019-01-21 fixed schematic label + correct firmware
2019-01-21 swapped RTS / DTR labels only
2019-01-21 added interactive BOM for v2 board
2019-01-23 updating more documention to v2a
2019-01-23 putting board pic back
2019-01-23 hardware readme
2019-01-23 unifying footprints
2019-01-23 updated interactive BOM
2019-01-23 adding useful circuitpython libraries
2019-01-23 submodule for circuitpython libs
2019-01-23 submodule fix
2019-01-23 submodule add
2019-01-23 adding library bundle for easy access
2019-01-23 cleaning up naming conventions
2019-01-23 updating readme
2019-01-23 adding new board image
2019-01-23 removing old board pic
2019-01-23 silkscreen fix
2019-02-06 minor tweaks to align with https://github.com/adafruit/uf2-samdx1/pull/45 and https://github.com/adafruit/circuitpython/pull/1523
    Adafruit pull requests:
    1. https://github.com/adafruit/circuitpython/pull/1523
    2. https://github.com/adafruit/uf2-samdx1/pull/45
2019-02-06 easier to find schematic
2019-02-10 clarifying ESP32 programming instructions
2019-02-10 typo in firmware readme
2019-02-19 modified board pinout to conform to adafruit feather standard :+1:
2019-02-20 directory for v21 (for reference)
2019-02-20 organizing directories
2019-02-20 fixing v22 interactive BOM link
2019-02-22 v22 cleanup and output files
2019-02-24 found esp32 programming bug causing OSError.
    See https://github.com/adafruit/Adafruit_CircuitPython_miniesptool/issues/9 for details.
2019-02-24 adding ESP32 arduino programming instructions
2019-02-25 ESP32 arduino programming
2019-02-25 adding esp arduino programming file
2019-02-28 adding images
2019-02-28 more images
2019-03-08 minor v2.2 fab tweaks
2019-04-13 fixing firmware naming convention
2019-04-18 sam32 block diagram and esp programming tweaks
2019-04-18 block diagram tweak
2019-04-18 relative links
2019-04-18 more relative paths
2019-05-04 adding v2.3 hardware
2019-05-08 adding esp32SPI firmware and clarification edits on v23 schematic
2019-05-09 adding v23 interactive BOM
2019-05-09 adding esp32spi example script
2019-05-09 fixing links
2019-05-15 fixed esp32spi firmware name
2019-05-15 updating board images
2019-05-15 lower resolution...
2019-05-16 clarifying firmware file
2019-06-10 making v23 easier to clone and work on locally
2019-06-10 updated board.png
2019-06-10 tigher crop on boad pics
2019-06-25 adding Mu fix
2019-07-11 adding deafult folder + cleaning/organizing
2019-07-17 fixed mac key icon
2019-08-22 adding version v2.4
2019-08-22 adding SAM32 guide to readme
2019-08-22 updating readme files with SAM32 guide
2019-08-22 cleaning up readme
2019-08-22 firmware cleaning and adding firmware_v24
2019-08-22 more firmware cleanup
2019-08-28 adding sam32 built-in library
2019-09-01 major sam32lib updates
2019-09-03 mini-ESP tool for flashing ESP32
2019-11-08 adding v25 which fixes concurrent ESP32/SD Card access
2019-11-25 adding v26
2019-11-25 updating interactive bom
2019-12-07 fancy-ness with v26 firmware
2020-01-16 adding v2.6 schematic pdf
2021-05-30 bringing sam32 to the CP7.0 age
2021-05-30 adding updated sam32lib to v26CP7
2021-06-07 sam32lib tweaks for CP7.0
2021-09-13 adding step file for v2.6
